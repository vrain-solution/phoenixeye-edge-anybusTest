# IAR project STM32H7_ABCC_Option_Card.ewp, settings and files
configuration EV-Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: $PROJ_DIR$; Core\Inc; Drivers\STM32H7xx_HAL_Driver\Inc; Drivers\STM32H7xx_HAL_Driver\Inc\Legacy; Drivers\CMSIS\Include; Drivers\CMSIS\Device\ST\STM32H7xx\Include; abcc_drv\inc; abcc_drv\src; abcc_drv\src\par; abcc_drv\src\par30; abcc_drv\src\serial; abcc_drv\src\spi; abcc_obj; abcc_obj\nw_obj; example_app; abcc_abp; abcc_adapt
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32H7_ABCC_Option_Card.srec
  ILINK.IlinkOutputFile: STM32H7_ABCC_Option_Card.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration 32KBLV-Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F407IG ST STM32F407IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F407xx; __STM_EVAL; USE_BOARD_SPECIFIC_ADI_SETUP
  ICCARM.CCIncludePath2: $PROJ_DIR$; Inc; Drivers\STM32F4xx_HAL_Driver\Inc; Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; Drivers\CMSIS\Include; Drivers\CMSIS\Device\ST\STM32F4xx\Include; abcc_drv\inc; abcc_drv\src; abcc_drv\src\par; abcc_drv\src\par30; abcc_drv\src\serial; abcc_drv\src\spi; abcc_obj; abcc_obj\nw_obj; example_app; abcc_abp; abcc_adapt
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: STM3240G_ABCC_Option_Card.out
  ILINK.IlinkIcfFile: STM3240G_ABCC_Option_Card.icf
  group abcc_abp
    abcc_abp/: abp.h abp_add.h abp_asm.h abp_bac.h abp_ccl.h abp_cipid.h abp_cnt.h abp_cop.h abp_cpc.h abp_cpn.h abp_dev.h abp_dpv0di.h abp_dpv1.h abp_eco.h abp_ect.h abp_eip.h abp_epl.h abp_er.h abp_etn.h abp_fsi.h abp_fusm.h abp_mdd.h abp_mod.h abp_nwccl.h abp_nwdpv1.h abp_nwetn.h abp_nwpnio.h abp_pnio.h abp_safe.h abp_smtp.h abp_soc.h abp_sync.h
  group abcc_adapt
    abcc_adapt/: abcc_drv_cfg.h abcc_identification.h abcc_obj_cfg.h abcc_platform_cfg.h abcc_sw_port.c abcc_sw_port.h abcc_sys_adapt.c abcc_td.h abcc_time.c abcc_time.h
  group abcc_drv
    abcc_drv/src/: abcc_cmd_seq.c abcc_cmd_seq.h abcc_debug_err.c abcc_debug_err.h abcc_drv_if.h abcc_handler.c abcc_handler.h abcc_link.c abcc_link.h abcc_mem.c abcc_mem.h abcc_remap.c abcc_seg.c abcc_seg.h abcc_setup.c abcc_setup.h abcc_timer.c abcc_timer.h
  group abcc_drv/par
    abcc_drv/src/par/: abcc_drv_par_if.h abcc_handler_par.c abcc_par_drv.c
  group abcc_drv/par30
    abcc_drv/src/par30/: abcc_drv_par30_if.h abcc_handler_par30.c abcc_par30_drv.c
  group abcc_drv/serial
    abcc_drv/src/serial/: abcc_crc16.c abcc_crc16.h abcc_drv_ser_if.h abcc_handler_ser.c abcc_serial_drv.c
  group abcc_drv/spi
    abcc_drv/src/spi/: abcc_crc32.c abcc_crc32.h abcc_drv_spi_if.h abcc_handler_spi.c abcc_spi_drv.c
  group abcc_drv_api
    abcc_drv/inc/: abcc.h abcc_ad_if.h abcc_cfg.h abcc_port.h abcc_sys_adapt.h abcc_sys_adapt_par.h abcc_sys_adapt_ser.h abcc_sys_adapt_spi.h
  group abcc_obj
    abcc_obj/: ad_obj.c ad_obj.h app_obj.c app_obj.h asm_obj.c asm_obj.h etn_obj.c etn_obj.h mqtt_obj.c mqtt_obj.h opcua_obj.c opcua_obj.h safe_obj.c safe_obj.h sync_obj.c sync_obj.h
  group abcc_obj/nw_obj
    abcc_obj/nw_obj/: bac.c bac.h ccl.c ccl.h cfn.c cfn.h cop.c cop.h dev.c dev.h dpv1.c dpv1.h ect.c ect.h eip.c eip.h epl.c epl.h mod.c mod.h prt.c prt.h
  group Application/EWARM
    Core/Startup/: startup_stm32h743xx.s
  group Application/User
    Core/Src/: bdma.c dma.c eth.c gpio.c i2c.c main.c spi.c stm32h7xx_hal_msp.c stm32h7xx_it.c system_stm32h7xx.c usart.c usb_otg.c
  group Drivers/STM32H7xx_HAL_Driver
    Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_usb.c
  group example_app
    example_app/: appl_abcc_handler.c appl_abcc_handler.h appl_adi_config.h appl_adimap_alltypes.c appl_adimap_bacnet.c appl_adimap_separate16.c appl_adimap_simple16.c appl_adimap_speed_example.c appl_adimap_sync.c appl_adimap_verif.c
