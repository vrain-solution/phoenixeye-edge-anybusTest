# Keil uVision project STM3240G_ABCC_Option_Card.uvproj, settings and files
target SDK (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F407IG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: app
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx, __STM_EVAL,USE_BOARD_SPECIFIC_ADI_SETUP, __USE_LCD
  c misc: --C99
  c include: .\Inc;.\Drivers\STM32F4xx_HAL_Driver\Inc;.\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy;.\Drivers\CMSIS\Include;.\Drivers\CMSIS\Device\ST\STM32F4xx\Include;.\abcc_abp;.\abcc_adapt;.\abcc_drv;.\abcc_drv\inc;.\abcc_drv\src;.\abcc_drv\src\par;.\abcc_drv\src\par30;.\abcc_drv\src\serial;.\abcc_drv\src\spi;.\abcc_obj;.\abcc_obj\nw_obj;.\example_app;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group Application/User
    ./Src/: gpio.c main.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c fsmc.c usart.c i2c.c tim.c adc.c dma.c
  group Drivers/CMSIS
    ./Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ./Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_sram.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c
  group abcc_abp
    ./abcc_abp/: abp.h abp_add.h abp_asm.h abp_bac.h abp_ccl.h abp_cipid.h abp_cnt.h abp_cop.h abp_cpc.h abp_cpn.h abp_dev.h abp_dpv0di.h abp_dpv1.h abp_eco.h abp_ect.h abp_eip.h abp_epl.h abp_er.h abp_etn.h abp_fsi.h abp_fusm.h abp_mdd.h abp_mod.h abp_nwccl.h abp_nwdpv1.h abp_nwetn.h abp_nwpnio.h abp_pnio.h abp_safe.h abp_smtp.h abp_soc.h abp_sync.h abp_mqtt.h abp_opcua.h
  group abcc_adapt
    ./abcc_adapt/: abcc_sw_port.c abcc_sys_adapt.c abcc_drv_cfg.h abcc_identification.h abcc_obj_cfg.h abcc_sw_port.h abcc_td.h Retarget.c Serial.c GLCD_16bitIF_STM32F4xx.c abcc_platform_cfg.h abcc_time.c abcc_time.h
  group abcc_drv
    ./abcc_drv/src/: abcc_debug_err.h abcc_debug_err.c abcc_handler.c abcc_link.c abcc_mem.c abcc_remap.c abcc_setup.c abcc_timer.c abcc_drv_if.h abcc_handler.h abcc_link.h abcc_mem.h abcc_setup.h abcc_timer.h abcc_cmd_seq.c abcc_cmd_seq.h abcc_seg.c abcc_seg.h
    ./abcc_drv/src/par/: abcc_handler_par.c abcc_par_drv.c abcc_drv_par_if.h
    ./abcc_drv/src/par30/: abcc_handler_par30.c abcc_par30_drv.c abcc_drv_par30_if.h
    ./abcc_drv/src/serial/: abcc_crc16.c abcc_handler_ser.c abcc_serial_drv.c abcc_crc16.h abcc_drv_ser_if.h
    ./abcc_drv/src/spi/: abcc_crc32.c abcc_handler_spi.c abcc_spi_drv.c abcc_crc32.h abcc_drv_spi_if.h
  group abcc_obj
    ./abcc_obj/: ad_obj.c app_obj.c etn_obj.c ad_obj.h app_obj.h etn_obj.h sync_obj.c sync_obj.h safe_obj.c safe_obj.h opcua_obj.c asm_obj.c mqtt_obj.c asm_obj.h mqtt_obj.h opcua_obj.h
    ./abcc_obj/nw_obj/: dpv1.c dev.c eip.c cop.c prt.c ect.c mod.c dpv1.h dev.h eip.h cop.h prt.h ect.h mod.h epl.c epl.h cfn.c ccl.c cfn.h ccl.h bac.c bac.h
  group example_app
    ./example_app/: appl_abcc_handler.c appl_adimap_alltypes.c appl_adimap_bacnet.c appl_adimap_separate16.c appl_adimap_simple16.c appl_adimap_speed_example.c appl_abcc_handler.h appl_adi_config.h appl_adimap_sync.c appl_adimap_verif.c appl_obj_port.c
    ./example_app_adapt/: appl_adimap_board_io.c
  group Documentation
    ./example_app/: Abstract.txt
  group abcc_drv_api
    ./abcc_drv/inc/: abcc_sys_adapt_spi.h abcc_cfg.h abcc_port.h abcc_sys_adapt_ser.h abcc_sys_adapt_par.h abcc_sys_adapt.h abcc_ad_if.h abcc.h
